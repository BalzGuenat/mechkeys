# Repository BalzGuenat/mechkeys (continued)

## KiCad design a1800-compat/a1800-compat.kicad_pcb (continued)

Parts:
C10, C15: 1µF; C_0805_HandSoldering
C11, C12, C13, C14: 0.1µF; C_0805_HandSoldering
R9, R11: 10kΩ; R_0805_HandSoldering
R10, R12: 30kΩ; R_0805_HandSoldering
SW_1, SW_2, SW_3, SW_4, SW_5, SW_6, SW_7, SW_8, SW_9, SW_10, SW_11, SW_12, SW_13, SW_14, SW_15, SW_16, SW_17, SW_18, SW_19, SW_20, SW_21, SW_22, SW_23, SW_24, SW_25, SW_26, SW_27, SW_28, SW_29, SW_30, SW_31, SW_32, SW_33, SW_34, SW_35, SW_36, SW_37, SW_38, SW_39, SW_40, SW_41, SW_42, SW_43, SW_44, SW_45, SW_46, SW_47, SW_48, SW_49, SW_50, SW_51, SW_52, SW_53, SW_54, SW_55, SW_56, SW_57, SW_58, SW_59, SW_60, SW_61, SW_62, SW_63, SW_64, SW_65, SW_66, SW_67, SW_68, SW_69, SW_70, SW_71, SW_72, SW_73, SW_74, SW_75, SW_76, SW_77, SW_78, SW_79, SW_80, SW_81, SW_82, SW_83, SW_84, SW_85, SW_86, SW_87, SW_88, SW_89, SW_90, SW_91, SW_92, SW_93, SW_94, SW_95, SW_96, SW_97, SW_98, SW_99, SW_100, SW_101, SW_102, SW_103, SW_104, SW_105, SW_106, SW_107, SW_108, SW_109, SW_110, SW_111, SW_112, SW_113, SW_114, SW_115: MX_LED
U2, U3: IS31FL3731; SSOP-28_5.3x10.2mm_Pitch0.65mm

Connections:
unnamed: C10.1, C12.1, C13.1, C15.1, R9.2, R11.2, U2.2 (VCC), U3.2 (VCC), U3.18 (AD)
unnamed: C11.1, U2.16 (C_FILT)
unnamed: C11.2, C13.2, C14.2, C15.2, R10.2, R12.2, U2.5 (GND), U2.18 (AD), U3.5 (GND)
unnamed: C14.1, U3.16 (C_FILT)
unnamed: R9.1, U2.3 (SDB)
unnamed: R10.1, U2.6 (R_EXT)
unnamed: R11.1, U3.3 (SDB)
unnamed: R12.1, U3.6 (R_EXT)
unnamed: U2.19 (SDA), U3.19 (SDA)
unnamed: U2.20 (SCL), U3.20 (SCL)
SW_A1: SW_1.K, SW_2.A, SW_3.A, SW_4.A, SW_5.A, SW_6.A, SW_7.A, SW_8.A, SW_9.A, SW_22.K, SW_40.K, SW_59.K, SW_60.K, SW_78.K, SW_97.K, SW_98.K, U2.21 (CA1); also elsewhere on the board
SW_A2: SW_1.A, SW_2.K, SW_23.K, SW_24.A, SW_25.A, SW_26.A, SW_27.A, SW_28.A, SW_29.A, SW_30.A, SW_41.K, SW_61.K, SW_79.K, SW_99.K, SW_100.K, U2.22 (CA2); also elsewhere on the board
SW_A3: SW_3.K, SW_22.A, SW_23.A, SW_24.K, SW_42.K, SW_43.A, SW_44.A, SW_45.A, SW_46.A, SW_47.A, SW_48.A, SW_62.K, SW_80.K, SW_101.K, U2.23 (CA3); also elsewhere on the board
SW_A4: SW_4.K, SW_25.K, SW_40.A, SW_41.A, SW_42.A, SW_43.K, SW_63.K, SW_64.A, SW_65.A, SW_66.A, SW_67.A, SW_68.A, SW_81.K, SW_97.A, SW_98.A, SW_99.A, SW_100.A, SW_101.A, U2.24 (CA4); also elsewhere on the board
SW_A5: SW_5.K, SW_26.K, SW_44.K, SW_59.A, SW_60.A, SW_61.A, SW_62.A, SW_63.A, SW_64.K, SW_82.K, SW_83.A, SW_84.A, SW_85.A, SW_86.A, U2.25 (CA5)
SW_A6: SW_6.K, SW_27.K, SW_45.K, SW_65.K, SW_78.A, SW_79.A, SW_80.A, SW_81.A, SW_82.A, SW_83.K, SW_102.A, SW_103.A, U2.26 (CA6); also elsewhere on the board
SW_A7: SW_7.K, SW_28.K, SW_46.K, SW_66.K, SW_84.K, U2.27 (CA7)
SW_A8: SW_8.K, SW_29.K, SW_47.K, SW_67.K, SW_85.K, SW_102.K, SW_103.K, U2.28 (CA8); also elsewhere on the board
SW_A9: SW_9.K, SW_30.K, SW_48.K, SW_68.K, SW_86.K, U2.1 (CA9)
SW_B1: SW_10.K, SW_11.A, SW_12.A, SW_13.A, SW_31.K, SW_49.K, SW_69.K, SW_87.K, SW_104.K, SW_105.K, SW_106.K, U2.7 (CB1)
SW_B2: SW_10.A, SW_11.K, SW_14.A, SW_15.A, SW_16.A, SW_17.A, SW_32.K, SW_50.K, SW_70.K, SW_88.K, SW_107.K, SW_108.K, SW_109.K, U2.8 (CB2)
SW_B3: SW_12.K, SW_33.K, SW_34.A, SW_35.A, SW_36.A, SW_37.A, SW_38.A, SW_39.A, SW_51.K, SW_71.K, SW_89.K, SW_110.K, U2.9 (CB3)
SW_B4: SW_13.K, SW_31.A, SW_32.A, SW_33.A, SW_34.K, SW_52.K, SW_53.A, SW_55.A, SW_56.A, SW_57.A, SW_58.A, SW_72.K, SW_73.K, SW_90.K, SW_113.K, U2.10 (CB4)
SW_B5: SW_35.K, SW_49.A, SW_50.A, SW_51.A, SW_52.A, SW_53.K, SW_54.K, SW_74.A, SW_75.A, SW_76.A, SW_77.A, SW_91.K, SW_96.K, U2.11 (CB5)
SW_B6: SW_14.K, SW_18.K, SW_36.K, SW_54.A, SW_55.K, SW_69.A, SW_70.A, SW_71.A, SW_72.A, SW_73.A, SW_74.K, SW_92.K, SW_93.A, SW_94.A, SW_95.A, SW_114.K, U2.12 (CB6)
SW_B7: SW_15.K, SW_19.K, SW_37.K, SW_56.K, SW_75.K, SW_87.A, SW_88.A, SW_89.A, SW_90.A, SW_91.A, SW_92.A, SW_93.K, SW_111.A, SW_112.A, SW_115.K, U2.13 (CB7)
SW_B8: SW_16.K, SW_20.K, SW_21.A, SW_38.K, SW_57.K, SW_76.K, SW_94.K, SW_96.A, SW_104.A, SW_105.A, SW_106.A, SW_107.A, SW_108.A, SW_109.A, SW_110.A, SW_111.K, SW_113.A, SW_114.A, SW_115.A, U2.14 (CB8)
SW_B9: SW_17.K, SW_18.A, SW_19.A, SW_20.A, SW_21.K, SW_39.K, SW_58.K, SW_77.K, SW_95.K, SW_112.K, U2.15 (CB9)

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
Board: 2 copper layers, 371.5 x 137.8 mm, 255 parts (128 on the bottom side), 170 nets.

Other parts of the board:
CHERRY: MX; CHERRY_PCB_625H_STAB
CHERRY#2: MX; CHERRY_PCB_6H_STAB
D104#2: D; SOD-123
STA: Stabilizer; CHERRY_PCB_200_STABILIZER
STA#2, STA#3, STA#4: Stabilizer; CHERRY_PCB_200_STABILIZER
SW_1u_1: MX_LED; MXALPS_REVERSE_LED
SW_1u_2, SW_1u_3, SW_1u_4, SW_1u_5: MX_LED; MXALPS

Their connections:
C1: SW_1u_1.SW2; also elsewhere on the board
C2: SW_1u_2.SW2; also elsewhere on the board
C3: SW_1u_3.SW1; also elsewhere on the board
C7: SW_1u_4.SW1; also elsewhere on the board
C10: SW_1u_5.SW1; also elsewhere on the board
unnamed 126: SW_1u_1.SW1; also elsewhere on the board
unnamed 127: SW_1u_4.SW2; also elsewhere on the board
R7: D104#2.1; also elsewhere on the board
SW_A1: SW_1u_1.K; also elsewhere on the board
SW_A2: SW_1u_2.K; also elsewhere on the board
SW_A3: SW_1u_3.K; also elsewhere on the board
SW_A4: SW_1u_1.A, SW_1u_2.A, SW_1u_3.A; also elsewhere on the board
SW_A6: SW_1u_4.A; also elsewhere on the board
SW_A8: SW_1u_4.K; also elsewhere on the board

## KiCad design LFK78/LFK78.kicad_pcb

Parts:
C4: 10µF; TantalC_SizeA_EIA-3216_HandSoldering
C5, C6, C7, C8, C12: 0.1µF; C_0805
C9, C10: 18pF; C_0805
C11: 1µF; C_0805
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79: D; Diode_DO-35_SOD27_Horizontal_RM10
F1: FP_Small; Fuse_SMD1206_HandSoldering
J1: USB_OTG; USB_Mini-B
R3: 150Ω; R_0805
R4, R5: 120Ω; R_0805
R6, R7: 22; R_0805
R8: 10k; R_0805
RGB33: Led_RGB_CA
SW1: SW_RST; SW_SPST_EVQP0
SW_A_40: MX_LED
SW_Alt_71, SW_Alt_73: MX_LED
SW_B_59: MX_LED
SW_Backspace_16: MX_LED
SW_C_57: MX_LED
SW_Caps_39: MX_LED
SW_Ctrl_69: MX_LED
SW_D_42: MX_LED
SW_Del_35: MX_LED
SW_E_24: MX_LED
SW_Enter_51: MX_LED
SW_F1_1, SW_F2_2, SW_F3_19, SW_F4_20, SW_F5_37, SW_F6_38, SW_F7_52, SW_F8_53, SW_F9_67, SW_F10_68: MX_LED
SW_F_43: MX_LED
SW_G_44: MX_LED
SW_H_45: MX_LED
SW_ISO_SLASH_79: MX_LED
SW_I_29: MX_LED
SW_Ins_17: MX_LED
SW_J_46: MX_LED
SW_K_47: MX_LED
SW_L_48: MX_LED
SW_M_61: MX_LED
SW_Menu_75: MX_LED
SW_N_60: MX_LED
SW_O_30: MX_LED
SW_P_31: MX_LED
SW_PgDn_36: MX_LED
SW_PgUp_18: MX_LED
SW_Q_22: MX_LED
SW_R_25: MX_LED
SW_S_41: MX_LED
SW_Shift_54, SW_Shift_65: MX_LED
SW_T_26: MX_LED
SW_Tab_21: MX_LED
SW_U_28: MX_LED
SW_V_58: MX_LED
SW_W_23: MX_LED
SW_Win_70, SW_Win_74: MX_LED
SW_X4Y1_3, SW_X5Y1_4, SW_X6Y1_5, SW_X7Y1_6, SW_X8Y1_7, SW_X8Y5_72, SW_X9Y1_8, SW_X10Y1_9, SW_X11Y1_10, SW_X12Y1_11, SW_X13Y1_12, SW_X13Y4_62, SW_X14Y1_13, SW_X14Y4_63, SW_X15Y1_14, SW_X15Y2_32, SW_X15Y3_49, SW_X15Y4_64, SW_X16Y1_15, SW_X16Y2_33, SW_X16Y3_50, SW_X17Y2_34, SW_X18Y5_76, SW_X19Y4_66, SW_X19Y5_77, SW_X20Y5_78: MX_LED
SW_X_56: MX_LED
SW_Y_27: MX_LED
SW_Z_55: MX_LED
U2: AT90USB1286; TQFP-64_14x14mm_Pitch0.8mm
X1: 16Mhz; Crystal_SMD_5032_4Pads
X2: PiezoelectricCrystal-TwoElectrodes_EN60617_04-07-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

Connections:
+5V: C4.1, C5.1, C6.1, C7.1, C8.1, F1.2, R8.2, RGB33.1, U2.3, U2.8, U2.21, U2.52, U2.64; also elsewhere on the board
AUDIO: U2.41, X2.2
C1: SW_F1_1.SW1, SW_F3_19.SW1, SW_F5_37.SW1, SW_F7_52.SW1, SW_F9_67.SW1, U2.51
C2: SW_F2_2.SW1, SW_F4_20.SW1, SW_F6_38.SW1, SW_F8_53.SW1, SW_F10_68.SW1, U2.50
C3: SW_Caps_39.SW1, SW_Ctrl_69.SW1, SW_Shift_54.SW1, SW_Tab_21.SW1, SW_X4Y1_3.SW1, U2.49; also elsewhere on the board
C4: SW_A_40.SW1, SW_ISO_SLASH_79.SW1, SW_Q_22.SW1, SW_Win_70.SW1, SW_X5Y1_4.SW1, U2.48; also elsewhere on the board
C5: SW_Alt_71.SW1, SW_S_41.SW1, SW_W_23.SW1, SW_X6Y1_5.SW1, SW_Z_55.SW1, U2.47; also elsewhere on the board
C6: SW_D_42.SW1, SW_E_24.SW1, SW_X7Y1_6.SW1, SW_X_56.SW1, U2.46; also elsewhere on the board
C7: SW_C_57.SW1, SW_F_43.SW1, SW_R_25.SW1, SW_X8Y1_7.SW1, U2.45
C8: SW_G_44.SW1, SW_T_26.SW1, SW_V_58.SW1, SW_X9Y1_8.SW1, U2.44
C9: SW_B_59.SW1, SW_H_45.SW1, SW_X8Y5_72.SW1, SW_X10Y1_9.SW1, SW_Y_27.SW1, U2.61
C10: SW_J_46.SW1, SW_N_60.SW1, SW_U_28.SW1, SW_X11Y1_10.SW1, U2.60
C11: SW_I_29.SW1, SW_K_47.SW1, SW_M_61.SW1, SW_X12Y1_11.SW1, U2.59
C12: SW_L_48.SW1, SW_O_30.SW1, SW_X13Y1_12.SW1, SW_X13Y4_62.SW1, U2.58
C13: SW_Alt_73.SW1, SW_P_31.SW1, SW_X14Y1_13.SW1, SW_X14Y4_63.SW1, SW_X15Y3_49.SW1, U2.57
C14: SW_Win_74.SW1, SW_X15Y1_14.SW1, SW_X15Y2_32.SW1, SW_X15Y4_64.SW1, SW_X16Y3_50.SW1, U2.56; also elsewhere on the board
C15: SW_Enter_51.SW1, SW_Menu_75.SW1, SW_Shift_65.SW1, SW_X16Y1_15.SW1, SW_X16Y2_33.SW1, U2.55; also elsewhere on the board
C16: SW_Backspace_16.SW1, SW_X17Y2_34.SW1, U2.54; also elsewhere on the board
C17: SW_Del_35.SW1, SW_Ins_17.SW1, SW_X18Y5_76.SW1, SW_X19Y5_77.SW1, U2.1
C18: SW_PgDn_36.SW1, SW_PgUp_18.SW1, SW_X19Y4_66.SW1, SW_X20Y5_78.SW1, U2.2
D+: R7.1, U2.5
D-: R6.1, U2.4
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J1.5 (GND), J1.6 (shield), SW1.1, U2.6, U2.22, U2.43, U2.53, U2.63, X2.1; also elsewhere on the board
LED_SCL: U2.25; also elsewhere on the board
LED_SDA: U2.26; also elsewhere on the board
MISO: U2.13
MOSI: U2.12
unnamed: C9.1, U2.24, X1.1
unnamed: C10.1, U2.23, X1.2
unnamed: C11.1, U2.7
unnamed: C12.1, U2.62
unnamed: D1.2 (A), SW_F1_1.SW2
unnamed: D2.2 (A), SW_F2_2.SW2
unnamed: D3.2 (A), SW_X4Y1_3.SW2
unnamed: D4.2 (A), SW_X5Y1_4.SW2
unnamed: D5.2 (A), SW_X6Y1_5.SW2
unnamed: D6.2 (A), SW_X7Y1_6.SW2
unnamed: D7.2 (A), SW_X8Y1_7.SW2
unnamed: D8.2 (A), SW_X9Y1_8.SW2
unnamed: D9.2 (A), SW_X10Y1_9.SW2
unnamed: D10.2 (A), SW_X11Y1_10.SW2
unnamed: D11.2 (A), SW_X12Y1_11.SW2
unnamed: D12.2 (A), SW_X13Y1_12.SW2
unnamed: D13.2 (A), SW_X14Y1_13.SW2
unnamed: D14.2 (A), SW_X15Y1_14.SW2
unnamed: D15.2 (A), SW_X16Y1_15.SW2
unnamed: D16.2 (A), SW_Backspace_16.SW2
unnamed: D17.2 (A), SW_Ins_17.SW2
unnamed: D18.2 (A), SW_PgUp_18.SW2
unnamed: D19.2 (A), SW_F3_19.SW2
unnamed: D20.2 (A), SW_F4_20.SW2
unnamed: D21.2 (A), SW_Tab_21.SW2
unnamed: D22.2 (A), SW_Q_22.SW2
unnamed: D23.2 (A), SW_W_23.SW2
unnamed: D24.2 (A), SW_E_24.SW2
unnamed: D25.2 (A), SW_R_25.SW2
unnamed: D26.2 (A), SW_T_26.SW2
unnamed: D27.2 (A), SW_Y_27.SW2
unnamed: D28.2 (A), SW_U_28.SW2
unnamed: D29.2 (A), SW_I_29.SW2
unnamed: D30.2 (A), SW_O_30.SW2
unnamed: D31.2 (A), SW_P_31.SW2
unnamed: D32.2 (A), SW_X15Y2_32.SW2
unnamed: D33.2 (A), SW_X16Y2_33.SW2
unnamed 85: D34.2 (A), SW_X17Y2_34.SW2; also elsewhere on the board
unnamed: D35.2 (A), SW_Del_35.SW2
unnamed: D36.2 (A), SW_PgDn_36.SW2
unnamed: D37.2 (A), SW_F5_37.SW2
unnamed: D38.2 (A), SW_F6_38.SW2
unnamed 90: D39.2 (A), SW_Caps_39.SW2; also elsewhere on the board
unnamed: D40.2 (A), SW_A_40.SW2
unnamed: D41.2 (A), SW_S_41.SW2
unnamed: D42.2 (A), SW_D_42.SW2
unnamed: D43.2 (A), SW_F_43.SW2
unnamed: D44.2 (A), SW_G_44.SW2
unnamed: D45.2 (A), SW_H_45.SW2
unnamed: D46.2 (A), SW_J_46.SW2
unnamed: D47.2 (A), SW_K_47.SW2
unnamed: D48.2 (A), SW_L_48.SW2
unnamed: D49.2 (A), SW_X15Y3_49.SW2
unnamed: D50.2 (A), SW_X16Y3_50.SW2
unnamed 102: D51.2 (A), SW_Enter_51.SW2; also elsewhere on the board
unnamed: D52.2 (A), SW_F7_52.SW2
unnamed: D53.2 (A), SW_F8_53.SW2
unnamed 105: D54.2 (A), SW_Shift_54.SW2; also elsewhere on the board
unnamed: D55.2 (A), SW_Z_55.SW2
unnamed: D56.2 (A), SW_X_56.SW2
unnamed: D57.2 (A), SW_C_57.SW2
unnamed: D58.2 (A), SW_V_58.SW2
unnamed: D59.2 (A), SW_B_59.SW2
unnamed: D60.2 (A), SW_N_60.SW2
unnamed: D61.2 (A), SW_M_61.SW2
unnamed: D62.2 (A), SW_X13Y4_62.SW2
unnamed: D63.2 (A), SW_X14Y4_63.SW2
unnamed: D64.2 (A), SW_X15Y4_64.SW2
unnamed: D65.2 (A), SW_Shift_65.SW2
unnamed: D66.2 (A), SW_X19Y4_66.SW2
unnamed: D67.2 (A), SW_F9_67.SW2
unnamed: D68.2 (A), SW_F10_68.SW2
unnamed 120: D69.2 (A), SW_Ctrl_69.SW2; also elsewhere on the board
unnamed 121: D70.2 (A), SW_Win_70.SW2; also elsewhere on the board
unnamed 122: D71.2 (A), SW_Alt_71.SW2; also elsewhere on the board
unnamed 123: D72.2 (A), SW_X8Y5_72.SW2; also elsewhere on the board
unnamed: D73.2 (A), SW_Alt_73.SW2
unnamed 125: D74.2 (A), SW_Win_74.SW2; also elsewhere on the board
unnamed 126: D75.2 (A), SW_Menu_75.SW2; also elsewhere on the board
unnamed: D76.2 (A), SW_X18Y5_76.SW2
unnamed: D77.2 (A), SW_X19Y5_77.SW2
unnamed: D78.2 (A), SW_X20Y5_78.SW2
unnamed: D79.2 (A), SW_ISO_SLASH_79.SW2
unnamed: F1.1, J1.1 (VCC)
unnamed: R3.1, RGB33.2 (R)
unnamed: R4.1, RGB33.3 (G)
unnamed: R5.1, RGB33.4 (B)
PWM_BLUE: R5.2, U2.17
PWM_GREEN: R4.2, U2.16
PWM_RED: R3.2, U2.15
R1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), U2.35
R2: D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U2.36
R3: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), U2.37
R4: D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D79.1 (K), U2.38
R5: D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), D73.1 (K), D74.1 (K), D75.1 (K), D77.1 (K), D78.1 (K), U2.39
RST: R8.1, SW1.2, U2.20
SCK: U2.11
USB+: J1.3 (D+), R7.2
USB-: J1.2 (D-), R6.2
