# Repository BalzGuenat/mechkeys (continued)

## KiCad design LFK78/LFK78.kicad_pcb (continued)

Parts:
C1, C13: 1µF; C_0805
C2, C3, C14, C15: 0.1µF; C_0805
R1, R2: 4.7KΩ; R_0805
R9, R12: 10KΩ; R_0805
R10, R11: 20KΩ; R_0805
RGB1, RGB2, RGB3, RGB4, RGB5, RGB6, RGB7, RGB8, RGB9, RGB10, RGB11, RGB12, RGB13, RGB14, RGB15, RGB16, RGB17, RGB18, RGB19, RGB20, RGB21, RGB22, RGB23, RGB24, RGB25, RGB26, RGB27, RGB28, RGB29, RGB30, RGB31, RGB32: Led_RGB_CA
SW_A_40: MX_LED
SW_Alt_71, SW_Alt_73: MX_LED
SW_B_59: MX_LED
SW_Backspace_16: MX_LED
SW_C_57: MX_LED
SW_Caps_39: MX_LED
SW_Ctrl_69: MX_LED
SW_D_42: MX_LED
SW_Del_35: MX_LED
SW_E_24: MX_LED
SW_Enter_51: MX_LED
SW_F1_1, SW_F2_2, SW_F3_19, SW_F4_20, SW_F5_37, SW_F6_38, SW_F7_52, SW_F8_53, SW_F9_67, SW_F10_68: MX_LED
SW_F_43: MX_LED
SW_G_44: MX_LED
SW_H_45: MX_LED
SW_I_29: MX_LED
SW_Ins_17: MX_LED
SW_J_46: MX_LED
SW_K_47: MX_LED
SW_L_48: MX_LED
SW_M_61: MX_LED
SW_Menu_75: MX_LED
SW_N_60: MX_LED
SW_O_30: MX_LED
SW_P_31: MX_LED
SW_PgDn_36: MX_LED
SW_PgUp_18: MX_LED
SW_Q_22: MX_LED
SW_R_25: MX_LED
SW_S_41: MX_LED
SW_Shift_54, SW_Shift_65: MX_LED
SW_T_26: MX_LED
SW_Tab_21: MX_LED
SW_U_28: MX_LED
SW_V_58: MX_LED
SW_W_23: MX_LED
SW_Win_70, SW_Win_74: MX_LED
SW_X4Y1_3, SW_X5Y1_4, SW_X6Y1_5, SW_X7Y1_6, SW_X8Y1_7, SW_X8Y5_72, SW_X9Y1_8, SW_X10Y1_9, SW_X11Y1_10, SW_X12Y1_11, SW_X13Y1_12, SW_X13Y4_62, SW_X14Y1_13, SW_X14Y4_63, SW_X15Y1_14, SW_X15Y2_32, SW_X15Y3_49, SW_X15Y4_64, SW_X16Y1_15, SW_X16Y2_33, SW_X16Y3_50, SW_X17Y2_34, SW_X18Y5_76, SW_X19Y4_66, SW_X19Y5_77, SW_X20Y5_78: MX_LED
SW_X_56: MX_LED
SW_Y_27: MX_LED
SW_Z_55: MX_LED
U3, U4: IS31FL3731; SSOP-28_5.3x10.2mm_Pitch0.65mm

Connections:
+5V: C1.1, C2.1, C13.1, C14.1, R1.1, R2.1, R9.2, R12.2, U3.2 (VCC), U4.2 (VCC), U4.18 (AD); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C13.2, C14.2, C15.2, R10.2, R11.2, U3.5 (GND), U3.18 (AD), U4.5 (GND); also elsewhere on the board
LED_SCL: R2.2, U3.20 (SCL), U4.20 (SCL); also elsewhere on the board
LED_SDA: R1.2, U3.19 (SDA), U4.19 (SDA); also elsewhere on the board
L_CA1: SW_F1_1.K, SW_F2_2.K, SW_F3_19.A, SW_F5_37.A, SW_F7_52.A, SW_F9_67.A, SW_X4Y1_3.K, SW_X5Y1_4.K, SW_X6Y1_5.K, SW_X7Y1_6.K, SW_X8Y1_7.K, SW_X9Y1_8.K, U3.21 (CA1)
L_CA2: SW_E_24.K, SW_F1_1.A, SW_F3_19.K, SW_F4_20.K, SW_F6_38.A, SW_F8_53.A, SW_F10_68.A, SW_Q_22.K, SW_R_25.K, SW_T_26.K, SW_Tab_21.K, SW_W_23.K, U3.22 (CA2)
L_CA3: SW_A_40.K, SW_Caps_39.K, SW_Ctrl_69.A, SW_D_42.K, SW_F2_2.A, SW_F4_20.A, SW_F5_37.K, SW_F6_38.K, SW_F_43.K, SW_G_44.K, SW_S_41.K, SW_Shift_54.A, U3.23 (CA3); also elsewhere on the board
L_CA4: SW_B_59.K, SW_C_57.K, SW_Caps_39.A, SW_F7_52.K, SW_F8_53.K, SW_Shift_54.K, SW_Tab_21.A, SW_V_58.K, SW_Win_70.A, SW_X4Y1_3.A, SW_X_56.K, SW_Z_55.K, U3.24 (CA4); also elsewhere on the board
L_CA5: SW_A_40.A, SW_Alt_71.K, SW_Ctrl_69.K, SW_F9_67.K, SW_F10_68.K, SW_Q_22.A, SW_Win_70.K, SW_X5Y1_4.A, SW_X8Y5_72.K, SW_Z_55.A, U3.25 (CA5); also elsewhere on the board
L_CA6: SW_Alt_71.A, SW_S_41.A, SW_W_23.A, SW_X6Y1_5.A, SW_X_56.A, U3.26 (CA6)
L_CA7: SW_C_57.A, SW_D_42.A, SW_E_24.A, SW_X7Y1_6.A, SW_X8Y5_72.A, U3.27 (CA7)
L_CA8: SW_F_43.A, SW_R_25.A, SW_V_58.A, SW_X8Y1_7.A, U3.28 (CA8)
L_CA9: SW_B_59.A, SW_G_44.A, SW_T_26.A, SW_X9Y1_8.A, U3.1 (CA9)
L_CB1: RGB1.2 (R), RGB2.2 (R), RGB3.2 (R), RGB4.2 (R), RGB5.2 (R), RGB6.2 (R), RGB7.2 (R), RGB8.2 (R), RGB9.1, U3.7 (CB1)
L_CB2: RGB1.1, RGB2.3 (G), RGB3.3 (G), RGB4.3 (G), RGB5.3 (G), RGB6.3 (G), RGB7.3 (G), RGB8.3 (G), RGB10.1, U3.8 (CB2)
L_CB3: RGB1.3 (G), RGB2.1, RGB3.4 (B), RGB4.4 (B), RGB5.4 (B), RGB6.4 (B), RGB7.4 (B), RGB8.4 (B), RGB11.1, U3.9 (CB3)
L_CB4: RGB1.4 (B), RGB2.4 (B), RGB3.1, RGB12.1, U3.10 (CB4)
L_CB5: RGB4.1, RGB13.1, U3.11 (CB5)
L_CB6: RGB5.1, RGB14.1, RGB15.4 (B), RGB16.4 (B), U3.12 (CB6)
L_CB7: RGB6.1, RGB9.4 (B), RGB10.4 (B), RGB11.4 (B), RGB12.4 (B), RGB13.4 (B), RGB14.4 (B), RGB15.1, RGB16.3 (G), U3.13 (CB7)
L_CB8: RGB7.1, RGB9.3 (G), RGB10.3 (G), RGB11.3 (G), RGB12.3 (G), RGB13.3 (G), RGB14.3 (G), RGB15.3 (G), RGB16.1, U3.14 (CB8)
L_CB9: RGB8.1, RGB9.2 (R), RGB10.2 (R), RGB11.2 (R), RGB12.2 (R), RGB13.2 (R), RGB14.2 (R), RGB15.2 (R), RGB16.2 (R), U3.15 (CB9)
unnamed: C3.1, U3.16 (C_FILT)
unnamed: C15.1, U4.16 (C_FILT)
unnamed: R9.1, U3.3 (SDB)
unnamed: R10.1, U3.6 (R_EXT)
unnamed: R11.1, U4.6 (R_EXT)
unnamed: R12.1, U4.3 (SDB)
R_CA1: SW_Alt_73.A, SW_Backspace_16.K, SW_H_45.A, SW_N_60.A, SW_X10Y1_9.K, SW_X11Y1_10.K, SW_X12Y1_11.K, SW_X13Y1_12.K, SW_X14Y1_13.K, SW_X15Y1_14.K, SW_X16Y1_15.K, SW_Y_27.A, U4.21 (CA1)
R_CA2: SW_I_29.K, SW_J_46.A, SW_M_61.A, SW_O_30.K, SW_P_31.K, SW_U_28.K, SW_Win_74.A, SW_X10Y1_9.A, SW_X15Y2_32.K, SW_X16Y2_33.K, SW_X17Y2_34.K, SW_Y_27.K, U4.22 (CA2)
R_CA3: SW_Enter_51.K, SW_H_45.K, SW_J_46.K, SW_K_47.K, SW_L_48.K, SW_Menu_75.A, SW_PgDn_36.K, SW_U_28.A, SW_X11Y1_10.A, SW_X13Y4_62.A, SW_X15Y3_49.K, SW_X16Y3_50.K, U4.23 (CA3); also elsewhere on the board
R_CA4: SW_I_29.A, SW_K_47.A, SW_M_61.K, SW_N_60.K, SW_PgUp_18.K, SW_Shift_65.K, SW_X12Y1_11.A, SW_X13Y4_62.K, SW_X14Y4_63.K, SW_X15Y4_64.K, SW_X18Y5_76.A, SW_X19Y4_66.K, U4.24 (CA4)
R_CA5: SW_Alt_73.K, SW_Del_35.K, SW_Ins_17.K, SW_L_48.A, SW_Menu_75.K, SW_O_30.A, SW_Win_74.K, SW_X13Y1_12.A, SW_X14Y4_63.A, SW_X18Y5_76.K, SW_X19Y5_77.K, SW_X20Y5_78.K, U4.25 (CA5); also elsewhere on the board
R_CA6: SW_P_31.A, SW_X14Y1_13.A, SW_X15Y3_49.A, SW_X15Y4_64.A, SW_X19Y5_77.A, U4.26 (CA6)
R_CA7: SW_Shift_65.A, SW_X15Y1_14.A, SW_X15Y2_32.A, SW_X16Y3_50.A, SW_X20Y5_78.A, U4.27 (CA7)
R_CA8: SW_Enter_51.A, SW_Ins_17.A, SW_X16Y1_15.A, SW_X16Y2_33.A, SW_X19Y4_66.A, U4.28 (CA8); also elsewhere on the board
R_CA9: SW_Backspace_16.A, SW_Del_35.A, SW_PgDn_36.A, SW_PgUp_18.A, SW_X17Y2_34.A, U4.1 (CA9)
R_CB1: RGB17.2 (R), RGB18.2 (R), RGB19.2 (R), RGB20.2 (R), RGB21.2 (R), RGB22.2 (R), RGB23.2 (R), RGB24.2 (R), RGB25.1, U4.7 (CB1)
R_CB2: RGB17.1, RGB18.3 (G), RGB19.3 (G), RGB20.3 (G), RGB21.3 (G), RGB22.3 (G), RGB23.3 (G), RGB24.3 (G), RGB26.1, U4.8 (CB2)
R_CB3: RGB17.3 (G), RGB18.1, RGB19.4 (B), RGB20.4 (B), RGB21.4 (B), RGB22.4 (B), RGB23.4 (B), RGB24.4 (B), RGB27.1, U4.9 (CB3)
R_CB4: RGB17.4 (B), RGB18.4 (B), RGB19.1, RGB28.1, U4.10 (CB4)
R_CB5: RGB20.1, RGB29.1, U4.11 (CB5)
R_CB6: RGB21.1, RGB30.1, RGB31.4 (B), RGB32.4 (B), U4.12 (CB6)
R_CB7: RGB22.1, RGB25.4 (B), RGB26.4 (B), RGB27.4 (B), RGB28.4 (B), RGB29.4 (B), RGB30.4 (B), RGB31.1, RGB32.3 (G), U4.13 (CB7)
R_CB8: RGB23.1, RGB25.3 (G), RGB26.3 (G), RGB27.3 (G), RGB28.3 (G), RGB29.3 (G), RGB30.3 (G), RGB31.3 (G), RGB32.1, U4.14 (CB8)
R_CB9: RGB24.1, RGB25.2 (R), RGB26.2 (R), RGB27.2 (R), RGB28.2 (R), RGB29.2 (R), RGB30.2 (R), RGB31.2 (R), RGB32.2 (R), U4.15 (CB9)

Board: 2 copper layers, 367.8 x 92.5 mm, 245 parts (140 on the bottom side), 165 nets.

Other parts of the board:
C16: 0.1µF; C_0805_HandSoldering
CHERRY: MX; CHERRY_PCB_625H_STABILIZER
R13: 20KΩ; R_0805_HandSoldering
STA: Stabilizer; CHERRY_PCB_200_STABILIZER_OUTLINE
STA#2, STA#3, STA#4: Stabilizer; CHERRY_PCB_200_STABILIZER_OUTLINE
SW_28: SW_28; MXALPS
SW_41: SW_41; MXALPS
SW_42: SW_42; MXALPS
SW_55: SW_55; MXALPS_REVERSE_LED
SW_56: SW_56; MXALPS
SW_57: SW_57; MXALPS
SW_58: SW_58; MXALPS
SW_59: SW_59; MXALPS_REVERSE_LED
SW_60: SW_60; MXALPS
SW_AEK_1: SW_60; MXALPS
SW_AEK_1#2, SW_AEK_1#3: SW_60; MXALPS_REVERSE_LED
SW_CapStep_39: MX_LED; MXALPS

Their connections:
C3: SW_42.SW1, SW_55.SW1, SW_CapStep_39.SW2; also elsewhere on the board
C4: SW_56.SW2; also elsewhere on the board
C5: SW_57.SW2; also elsewhere on the board
C6: SW_58.SW1; also elsewhere on the board
C14: SW_59.SW2, SW_AEK_1.SW2; also elsewhere on the board
C15: SW_41.SW1, SW_60.SW2, SW_AEK_1#2.SW2, SW_AEK_1#3.SW1; also elsewhere on the board
C16: SW_28.SW2; also elsewhere on the board
GND: C16.2, R13.2; also elsewhere on the board
L_CA3: SW_55.A, SW_CapStep_39.K; also elsewhere on the board
L_CA4: SW_CapStep_39.A; also elsewhere on the board
L_CA5: SW_55.K; also elsewhere on the board
unnamed 85: SW_28.SW1; also elsewhere on the board
unnamed 90: SW_CapStep_39.SW1; also elsewhere on the board
unnamed 102: SW_41.SW2; also elsewhere on the board
unnamed 105: SW_42.SW2; also elsewhere on the board
unnamed 120: SW_55.SW2; also elsewhere on the board
unnamed 121: SW_56.SW1; also elsewhere on the board
unnamed 122: SW_57.SW1; also elsewhere on the board
unnamed 123: SW_58.SW2; also elsewhere on the board
unnamed 125: SW_59.SW1, SW_AEK_1.SW1; also elsewhere on the board
unnamed 126: SW_60.SW1, SW_AEK_1#2.SW1, SW_AEK_1#3.SW2; also elsewhere on the board
R_CA3: SW_28.K, SW_59.A, SW_60.A, SW_AEK_1.A, SW_AEK_1#2.A, SW_AEK_1#3.A; also elsewhere on the board
R_CA5: SW_59.K, SW_60.K, SW_AEK_1.K, SW_AEK_1#2.K, SW_AEK_1#3.K; also elsewhere on the board
R_CA8: SW_28.A; also elsewhere on the board

## KiCad design BluePad/BluePad.kicad_pcb

Board: 2 copper layers, 76.2 x 95.2 mm, 90 parts (47 on the bottom side), 71 nets.

Parts:
C1: 10µF; TantalC_SizeA_EIA-3216_HandSoldering
C2, C3, C4, C5, C9, C11, C12: 0.1µF; C_0805_HandSoldering
C6, C7: 18pF; C_0805_HandSoldering
C8, C10: 1µF; C_0805_HandSoldering
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: D; Diode_DO-35_SOD27_Horizontal_RM10
F1: FP_Small; Fuse_SMD1206_HandSoldering
J1: USB_OTG; USB_Mini-B
JP_ENTER_1, JP_ENTER_2, JP_ENTER_3, JP_ENTER_4: Jumper_NC_Small; R_0805_HandSoldering
JP_PLUS_1, JP_PLUS_2, JP_PLUS_3, JP_PLUS_4: Jumper_NC_Small; R_0805_HandSoldering
JP_SW8_1, JP_SW8_2, JP_SW12_1, JP_SW12_2, JP_SW16_1, JP_SW16_2, JP_SW20_1, JP_SW20_2: Jumper_NO_Small; R_0805_HandSoldering
R4, R5: 22; R_0805_HandSoldering
R6: 10k; R_0805_HandSoldering
R7, R8: 4.7KΩ; R_0805_HandSoldering
R9: 100KΩ; R_0805_HandSoldering
R10: 20KΩ; R_0805_HandSoldering
RGB8, RGB9, RGB10, RGB11, RGB12, RGB13: Led_RGB_CA; SMP4-RGB
SW1: SW_RST; SW_SPST_EVQP0
SW_1, SW_2, SW_2U_0_1, SW_2U_PLUS_1, SW_3, SW_4, SW_5, SW_6, SW_7, SW_8, SW_9, SW_10, SW_11, SW_12, SW_13, SW_14, SW_15, SW_16, SW_17, SW_18, SW_19, SW_20: MX_LED; MXALPS
SW_2U_ENTER_1: MX_LED; MXALPS_LED_PANEL
U1: ATMEGA32U4RC-A; TQFP-44_10x10mm_Pitch0.8mm
U2: IS31FL3731; SSOP-28_5.3x10.2mm_Pitch0.65mm
X1: 16Mhz; Crystal_SMD_5032_4Pads

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C10.1, C11.1, F1.2, R6.2, R7.1, R8.1, U1.2, U1.7, U1.14, U1.24, U1.34, U1.44, U2.2
C1: SW_1.SW1, SW_2U_0_1.SW1, SW_5.SW1, SW_9.SW1, SW_13.SW1, SW_17.SW1, U1.31
C2: SW_2.SW1, SW_6.SW1, SW_10.SW1, SW_14.SW1, SW_18.SW1, U1.32
C3: SW_3.SW1, SW_7.SW1, SW_11.SW1, SW_15.SW1, SW_19.SW1, U1.20
C4: JP_ENTER_1.2, JP_PLUS_1.2, JP_SW8_1.2, JP_SW16_1.2, SW_4.SW1, SW_12.SW1, SW_20.SW1, U1.21
CA1: SW_1.A, SW_2.K, SW_2U_0_1.A, SW_3.K, SW_4.K, SW_5.K, SW_6.K, SW_7.K, SW_8.K, SW_9.A, SW_17.A, U2.21
CA2: JP_SW12_1.2, SW_1.K, SW_2.A, SW_10.A, SW_11.K, SW_13.K, SW_14.K, SW_15.K, SW_16.K, SW_18.A, U2.22
CA3: JP_ENTER_3.1, JP_PLUS_3.1, JP_SW20_1.2, SW_3.A, SW_9.K, SW_10.K, SW_11.A, SW_19.A, U2.23
CA4: JP_ENTER_4.2, JP_SW12_2.2, SW_2U_0_1.K, SW_4.A, SW_17.K, SW_18.K, SW_19.K, U2.24
CA5: JP_SW20_2.1, SW_5.A, SW_13.A, U2.25
CA6: JP_PLUS_4.2, SW_6.A, SW_14.A, U2.26
CA7: SW_7.A, SW_15.A, U2.27
CA8: SW_8.A, SW_16.A, U2.28
CB1: RGB8.1, U2.7
CB2: RGB9.1, U2.8
CB3: RGB10.1, U2.9
CB4: RGB11.1, U2.10
CB5: RGB12.1, U2.11
CB6: RGB13.1, U2.12
CB7: RGB8.4, RGB9.4, RGB10.4, RGB11.4, RGB12.4, RGB13.4, U2.13
CB8: RGB8.3, RGB9.3, RGB10.3, RGB11.3, RGB12.3, RGB13.3, U2.14
CB9: RGB8.2, RGB9.2, RGB10.2, RGB11.2, RGB12.2, RGB13.2, U2.15
D+: R5.1, U1.4
D-: R4.1, U1.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J1.5, J1.6, R9.2, R10.2, SW1.1, U1.5, U1.15, U1.23, U1.33, U1.35, U1.43, U2.5, U2.18
LED_NSRT: R9.1, U1.36, U2.3
LED_SCL: R8.2, U1.18, U2.20
LED_SDA: R7.2, U1.19, U2.19
NET_ENTER_SW1: JP_ENTER_1.1, JP_SW20_1.1, SW_2U_ENTER_1.SW1, SW_20.K
NET_ENTER_SW2: JP_ENTER_2.1, JP_SW20_2.2, SW_2U_ENTER_1.SW2, SW_20.A
NET_PLUS_SW1: JP_PLUS_1.1, JP_SW12_1.1, SW_2U_PLUS_1.SW1, SW_12.K
NET_PLUS_SW2: JP_PLUS_2.1, JP_SW12_2.1, SW_2U_PLUS_1.SW2, SW_12.A
NET_SW8_1: JP_PLUS_3.2, JP_SW8_1.1, SW_2U_PLUS_1.K, SW_8.SW1
NET_SW8_2: JP_PLUS_4.1, JP_SW8_2.1, SW_2U_PLUS_1.A, SW_8.SW2
NET_SW16_1: JP_ENTER_3.2, JP_SW16_1.1, SW_2U_ENTER_1.K, SW_16.SW1
NET_SW16_2: JP_ENTER_4.1, JP_SW16_2.1, SW_2U_ENTER_1.A, SW_16.SW2
unnamed: C6.1, U1.17, X1.1
unnamed: C7.1, U1.16, X1.2
unnamed: C8.1, U1.6
unnamed: C9.1, U1.42
unnamed: C12.1, U2.16
unnamed: D1.2, SW_1.SW2
unnamed: D2.2, SW_2.SW2
unnamed: D3.2, SW_3.SW2
unnamed: D4.2, SW_4.SW2
unnamed: D5.2, SW_5.SW2
unnamed: D6.2, SW_6.SW2
unnamed: D7.2, SW_7.SW2
unnamed: D8.2, JP_PLUS_2.2, JP_SW8_2.2
unnamed: D9.2, SW_9.SW2
unnamed: D10.2, SW_10.SW2
unnamed: D11.2, SW_11.SW2
unnamed: D12.2, SW_12.SW2
unnamed: D13.2, SW_13.SW2
unnamed: D14.2, SW_14.SW2
unnamed: D15.2, SW_15.SW2
unnamed: D16.2, JP_ENTER_2.2, JP_SW16_2.2
unnamed: D17.2, SW_2U_0_1.SW2, SW_17.SW2
unnamed: D18.2, SW_18.SW2
unnamed: D19.2, SW_19.SW2
unnamed: D20.2, SW_20.SW2
unnamed: F1.1, J1.1
unnamed: R10.1, U2.6
R1: D1.1, D2.1, D3.1, D4.1, U1.8
R2: D5.1, D6.1, D7.1, D8.1, U1.9
R3: D9.1, D10.1, D11.1, D12.1, U1.10
R4: D13.1, D14.1, D15.1, D16.1, U1.11
R5: D17.1, D18.1, D19.1, D20.1, U1.28
RST: R6.1, SW1.2, U1.13
USB+: J1.3, R5.2
USB-: J1.2, R4.2

## KiCad design 103key-project/103key.kicad_pcb

Board: 2 copper layers, 409.5 x 124.0 mm, 215 parts (1 on the bottom side), 124 nets.

Parts:
CHERRY: MX; CHERRY_PCB_225H_STABILIZER
CHERRY#2: MX; CHERRY_PCB_275H_STABILIZER
CHERRY#3, CHERRY#4: MX; CHERRY_PCB_200H_STABILIZER
CHERRY#5: MX; CHERRY_PCB_225H_STABILIZER
CHERRY#6: MX; CHERRY_PCB_625H_STABILIZER
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D98, D99, D100, D101, D102, D103: D; Diode_DO-35_SOD27_Horizontal_RM10
STA: Stabilizer; CHERRY_PCB_200_STABILIZER
STA#2: Stabilizer; CHERRY_PCB_200_STABILIZER
SW_0_92, SW_1_75, SW_2_76, SW_3_77, SW_4_59, SW_5_60, SW_6_61, SW_7_39, SW_8_40, SW_9_41: MX_LED; MXALPS
SW_A_63: MX_LED; MXALPS
SW_Alt_96, SW_Alt_98: MX_LED; MXALPS
SW_B_84: MX_LED; MXALPS
SW_Backspace_36: MX_LED; MXALPS
SW_C_82: MX_LED; MXALPS
SW_Caps_62: MX_LED; MXALPS
SW_Ctrl_94: MX_LED; MXALPS
SW_D_65: MX_LED; MXALPS
SW_Del_57: MX_LED; MXALPS
SW_E_46: MX_LED; MXALPS
SW_End_18: MX_LED; MXALPS
SW_Enter_74, SW_Enter_78: MX_LED; MXALPS
SW_Esc_4: MX_LED; MXALPS
SW_F1_5, SW_F2_6, SW_F3_7, SW_F4_8, SW_F5_9, SW_F6_10, SW_F7_11, SW_F8_12, SW_F9_13, SW_F10_14, SW_F11_15, SW_F12_16: MX_LED; MXALPS
SW_F_66: MX_LED; MXALPS
SW_G_67: MX_LED; MXALPS
SW_H_68: MX_LED; MXALPS
SW_Home_17: MX_LED; MXALPS
SW_I_51: MX_LED; MXALPS
SW_Ins_37: MX_LED; MXALPS
SW_J_69: MX_LED; MXALPS
SW_K_70: MX_LED; MXALPS
SW_L_71: MX_LED; MXALPS
SW_M_86: MX_LED; MXALPS
SW_Menu_100: MX_LED; MXALPS
SW_N_85: MX_LED; MXALPS
SW_Num_19: MX_LED; MXALPS
SW_O_52: MX_LED; MXALPS
SW_P_53: MX_LED; MXALPS
SW_Pause_3: MX_LED; MXALPS
SW_PgDn_58: MX_LED; MXALPS
SW_PgUp_38: MX_LED; MXALPS
SW_PrtSc_1: MX_LED; MXALPS
SW_Q_44: MX_LED; MXALPS
SW_R_47: MX_LED; MXALPS
SW_S_64: MX_LED; MXALPS
SW_Scroll_2: MX_LED; MXALPS
SW_Shift_79, SW_Shift_90: MX_LED; MXALPS
SW_T_48: MX_LED; MXALPS
SW_Tab_43: MX_LED; MXALPS
SW_U_50: MX_LED; MXALPS
SW_V_83: MX_LED; MXALPS
SW_W_45: MX_LED; MXALPS
SW_Win_95, SW_Win_99: MX_LED; MXALPS
SW_X3Y3_20, SW_X4Y3_21, SW_X4Y7_93, SW_X5Y3_22, SW_X5Y4_42, SW_X6Y3_23, SW_X7Y3_24, SW_X8Y3_25, SW_X9Y3_26, SW_X10Y3_27, SW_X10Y7_97, SW_X11Y3_28, SW_X12Y3_29, SW_X13Y3_30, SW_X14Y3_31, SW_X15Y3_32, SW_X15Y6_87, SW_X16Y3_33, SW_X16Y6_88, SW_X17Y3_34, SW_X17Y4_54, SW_X17Y5_72, SW_X17Y6_89, SW_X18Y3_35, SW_X18Y4_55, SW_X18Y5_73, SW_X19Y4_56, SW_X20Y7_101, SW_X21Y6_91, SW_X21Y7_102, SW_X22Y7_103: MX_LED; MXALPS
SW_X_81: MX_LED; MXALPS
SW_Y_49: MX_LED; MXALPS
SW_Z_80: MX_LED; MXALPS
U1: Teensy_3.2; Teensy3.2

Connections:
C1: SW_0_92.SW1, SW_1_75.SW1, SW_2_76.SW1, SW_4_59.SW1, SW_5_60.SW1, SW_7_39.SW1, SW_8_40.SW1, SW_Num_19.SW1, SW_PrtSc_1.SW1, SW_Scroll_2.SW1, SW_X3Y3_20.SW1, U1.20
C2: SW_3_77.SW1, SW_6_61.SW1, SW_9_41.SW1, SW_Ctrl_94.SW1, SW_Enter_78.SW1, SW_Esc_4.SW1, SW_Pause_3.SW1, SW_X4Y3_21.SW1, SW_X4Y7_93.SW1, SW_X5Y3_22.SW1, SW_X5Y4_42.SW1, U1.19
C3: SW_A_63.SW1, SW_Caps_62.SW1, SW_F1_5.SW1, SW_F2_6.SW1, SW_Q_44.SW1, SW_Shift_79.SW1, SW_Tab_43.SW1, SW_Win_95.SW1, SW_X6Y3_23.SW1, SW_X7Y3_24.SW1, SW_Z_80.SW1, U1.18
C4: SW_Alt_96.SW1, SW_C_82.SW1, SW_D_65.SW1, SW_E_46.SW1, SW_F3_7.SW1, SW_F4_8.SW1, SW_S_64.SW1, SW_W_45.SW1, SW_X8Y3_25.SW1, SW_X9Y3_26.SW1, SW_X_81.SW1, U1.17
C5: SW_B_84.SW1, SW_F5_9.SW1, SW_F6_10.SW1, SW_F_66.SW1, SW_G_67.SW1, SW_R_47.SW1, SW_T_48.SW1, SW_V_83.SW1, SW_X10Y3_27.SW1, SW_X10Y7_97.SW1, SW_X11Y3_28.SW1, U1.16
C6: SW_Alt_98.SW1, SW_F7_11.SW1, SW_F8_12.SW1, SW_H_68.SW1, SW_J_69.SW1, SW_M_86.SW1, SW_N_85.SW1, SW_U_50.SW1, SW_X12Y3_29.SW1, SW_X13Y3_30.SW1, SW_Y_49.SW1, U1.15
C7: SW_F9_13.SW1, SW_F10_14.SW1, SW_I_51.SW1, SW_K_70.SW1, SW_L_71.SW1, SW_O_52.SW1, SW_Win_99.SW1, SW_X14Y3_31.SW1, SW_X15Y3_32.SW1, SW_X15Y6_87.SW1, SW_X16Y6_88.SW1, U1.14
C8: SW_F11_15.SW1, SW_F12_16.SW1, SW_Menu_100.SW1, SW_P_53.SW1, SW_Shift_90.SW1, SW_X16Y3_33.SW1, SW_X17Y3_34.SW1, SW_X17Y4_54.SW1, SW_X17Y5_72.SW1, SW_X17Y6_89.SW1, SW_X18Y5_73.SW1, U1.13
C9: SW_Backspace_36.SW1, SW_End_18.SW1, SW_Enter_74.SW1, SW_Home_17.SW1, SW_X18Y3_35.SW1, SW_X18Y4_55.SW1, SW_X19Y4_56.SW1, SW_X20Y7_101.SW1, SW_X21Y6_91.SW1, SW_X21Y7_102.SW1, SW_X22Y7_103.SW1, U1.3
C10: SW_Del_57.SW1, SW_Ins_37.SW1, SW_PgDn_58.SW1, SW_PgUp_38.SW1, U1.4
unnamed: D1.2, SW_PrtSc_1.SW2
unnamed: D2.2, SW_Scroll_2.SW2
unnamed: D3.2, SW_Pause_3.SW2
unnamed: D4.2, SW_Esc_4.SW2
unnamed: D5.2, SW_F1_5.SW2
unnamed: D6.2, SW_F2_6.SW2
unnamed: D7.2, SW_F3_7.SW2
unnamed: D8.2, SW_F4_8.SW2
unnamed: D9.2, SW_F5_9.SW2
unnamed: D10.2, SW_F6_10.SW2
unnamed: D11.2, SW_F7_11.SW2
unnamed: D12.2, SW_F8_12.SW2
unnamed: D13.2, SW_F9_13.SW2
unnamed: D14.2, SW_F10_14.SW2
unnamed: D15.2, SW_F11_15.SW2
unnamed: D16.2, SW_F12_16.SW2
unnamed: D17.2, SW_Home_17.SW2
unnamed: D18.2, SW_End_18.SW2
unnamed: D19.2, SW_Num_19.SW2
unnamed: D20.2, SW_X3Y3_20.SW2
unnamed: D21.2, SW_X4Y3_21.SW2
unnamed: D22.2, SW_X5Y3_22.SW2
unnamed: D23.2, SW_X6Y3_23.SW2
unnamed: D24.2, SW_X7Y3_24.SW2
unnamed: D25.2, SW_X8Y3_25.SW2
unnamed: D26.2, SW_X9Y3_26.SW2
unnamed: D27.2, SW_X10Y3_27.SW2
unnamed: D28.2, SW_X11Y3_28.SW2
unnamed: D29.2, SW_X12Y3_29.SW2
unnamed: D30.2, SW_X13Y3_30.SW2
unnamed: D31.2, SW_X14Y3_31.SW2
unnamed: D32.2, SW_X15Y3_32.SW2
unnamed: D33.2, SW_X16Y3_33.SW2
unnamed: D34.2, SW_X17Y3_34.SW2
unnamed: D35.2, SW_X18Y3_35.SW2
unnamed: D36.2, SW_Backspace_36.SW2
unnamed: D37.2, SW_Ins_37.SW2
unnamed: D38.2, SW_PgUp_38.SW2
unnamed: D39.2, SW_7_39.SW2
unnamed: D40.2, SW_8_40.SW2
unnamed: D41.2, SW_9_41.SW2
unnamed: D42.2, SW_X5Y4_42.SW2
unnamed: D43.2, SW_Tab_43.SW2
unnamed: D44.2, SW_Q_44.SW2
unnamed: D45.2, SW_W_45.SW2
unnamed: D46.2, SW_E_46.SW2
unnamed: D47.2, SW_R_47.SW2
unnamed: D48.2, SW_T_48.SW2
unnamed: D49.2, SW_Y_49.SW2
unnamed: D50.2, SW_U_50.SW2
unnamed: D51.2, SW_I_51.SW2
unnamed: D52.2, SW_O_52.SW2
unnamed: D53.2, SW_P_53.SW2
unnamed: D54.2, SW_X17Y4_54.SW2
unnamed: D55.2, SW_X18Y4_55.SW2
unnamed: D56.2, SW_X19Y4_56.SW2
unnamed: D57.2, SW_Del_57.SW2
unnamed: D58.2, SW_PgDn_58.SW2
unnamed: D59.2, SW_4_59.SW2
unnamed: D60.2, SW_5_60.SW2
unnamed: D61.2, SW_6_61.SW2
unnamed: D62.2, SW_Caps_62.SW2
unnamed: D63.2, SW_A_63.SW2
unnamed: D64.2, SW_S_64.SW2
unnamed: D65.2, SW_D_65.SW2
unnamed: D66.2, SW_F_66.SW2
unnamed: D67.2, SW_G_67.SW2
unnamed: D68.2, SW_H_68.SW2
unnamed: D69.2, SW_J_69.SW2
unnamed: D70.2, SW_K_70.SW2
unnamed: D71.2, SW_L_71.SW2
unnamed: D72.2, SW_X17Y5_72.SW2
unnamed: D73.2, SW_X18Y5_73.SW2
unnamed: D74.2, SW_Enter_74.SW2
unnamed: D75.2, SW_1_75.SW2
unnamed: D76.2, SW_2_76.SW2
unnamed: D77.2, SW_3_77.SW2
unnamed: D78.2, SW_Enter_78.SW2
unnamed: D79.2, SW_Shift_79.SW2
unnamed: D80.2, SW_Z_80.SW2
unnamed: D81.2, SW_X_81.SW2
unnamed: D82.2, SW_C_82.SW2
unnamed: D83.2, SW_V_83.SW2
unnamed: D84.2, SW_B_84.SW2
unnamed: D85.2, SW_N_85.SW2
unnamed: D86.2, SW_M_86.SW2
unnamed: D87.2, SW_X15Y6_87.SW2
unnamed: D88.2, SW_X16Y6_88.SW2
unnamed: D89.2, SW_X17Y6_89.SW2
unnamed: D90.2, SW_Shift_90.SW2
unnamed: D91.2, SW_X21Y6_91.SW2
unnamed: D92.2, SW_0_92.SW2
unnamed: D93.2, SW_X4Y7_93.SW2
unnamed: D94.2, SW_Ctrl_94.SW2
unnamed: D95.2, SW_Win_95.SW2
unnamed: D96.2, SW_Alt_96.SW2
unnamed: D97.2, SW_X10Y7_97.SW2
unnamed: D98.2, SW_Alt_98.SW2
unnamed: D99.2, SW_Win_99.SW2
unnamed: D100.2, SW_Menu_100.SW2
unnamed: D101.2, SW_X20Y7_101.SW2
unnamed: D102.2, SW_X21Y7_102.SW2
unnamed: D103.2, SW_X22Y7_103.SW2
R1: D1.1, D3.1, D5.1, D7.1, D9.1, D11.1, D13.1, D15.1, D17.1, U1.2
R2: D2.1, D4.1, D6.1, D8.1, D10.1, D12.1, D14.1, D16.1, D18.1, U1.1
R3: D19.1, D21.1, D23.1, D25.1, D27.1, D29.1, D31.1, D33.1, D35.1, D37.1, U1.0
R4: D20.1, D22.1, D24.1, D26.1, D28.1, D30.1, D32.1, D34.1, D36.1, D38.1, U1.10
R5: D39.1, D41.1, D43.1, D45.1, D47.1, D49.1, D51.1, D53.1, D55.1, D57.1, U1.9
R6: D40.1, D42.1, D44.1, D46.1, D48.1, D50.1, D52.1, D54.1, D56.1, D58.1, U1.8
R7: D59.1, D61.1, D62.1, D64.1, D66.1, D68.1, D70.1, D72.1, D74.1, U1.7
R8: D60.1, D63.1, D65.1, D67.1, D69.1, D71.1, D73.1, D78.1, D91.1, U1.6
R9: D75.1, D77.1, D79.1, D81.1, D83.1, D85.1, D87.1, D89.1, D101.1, U1.5
R10: D76.1, D80.1, D82.1, D84.1, D86.1, D88.1, D90.1, D94.1, D102.1, U1.11
R11: D92.1, D93.1, D95.1, D96.1, D97.1, D98.1, D99.1, D100.1, D103.1, U1.12

## Commit log

2016-05-28 Added mounting holes, cleaned up silkscreen
2016-05-28 Add gerber files
2016-05-28 Add cad files for plate/sandwich
2016-06-05 Updated f-row to match standard spacing
2016-06-05 Update keyboard definitions for standard f-row
2016-06-05 Removed outdated gerbers/plates
2016-06-05 Plates for updated f-row
2016-06-05 Gerbers for updated f-row
2016-06-05 stitched ground planes
2016-06-06 Gerbers for MF68+10
2016-06-06 Added PCB stabilizers to both 103 key and MF68+10
2016-06-20 Reworked RGB LED and added connector for off board LED.
    Shrunk mounting holes and removed plating.
2016-06-22 Changed key matrix to 10x11 to free up 3 teensy pins
2016-06-23 Trace cleanup
2016-06-24 Final commit for order placed on 6/23/2016
2016-07-06 New cad files for sandwhich type case
2016-07-07 Updated plate readme
2016-07-13 Moved diodes out of the way of the cherry stabilizers
2016-07-15 Removed dependancy on the kicad libs, now generates pcb file from text templates.
2016-07-15 tweak diode placement
2016-07-20 Adding the current 78k layout. MX+ALPS, LEDs in switches and 12 underglow RGB LEDs.
2016-07-23 1st pass at layout. Needs packages verified, and underglow LEDs added
2016-07-23 RGB LEDs placed
2016-07-23 100% Routed- Need to verify all packages, clean up labels and tracks.
2016-07-24 Packages verified, BOM w/part numbers created
2016-07-24 Fixed clearance issues.
2016-07-29 17/20 key keypad
2016-08-28 Renamed BlueWeevil to LFK78
2016-09-01 Added reversible mini layout
2016-09-01 Removed .rpt files from git
2016-09-01 Moved diodes that interfered with stab wire.
2016-09-24 Added drawings for sandwich case
2016-09-24 info for case files
2016-09-24 typo
2016-09-24 readme update
2016-10-09 Fixed incorrect documentation
2016-11-03 LFK78 RevC addedd
2016-11-03 Add alps1800
2016-11-25 Added zipped case drawings
2016-11-27 revC board completed with USB and mounting holes verified for VA68M case.
2016-12-15 Rollback LFK78 to the actual oder made in Oct
2016-12-15 Clean up of final LFK-RevC
2016-12-16 Supporting documentation
2016-12-16 Added zipped version of drawing, file is corrupted otherwise. (line ending conversion??)
2016-12-17 Cherry plate for Varmilo
2017-01-02 Updating the 1800 board, adding a couple of related proects
2017-01-15 Adding LFK RevD
2017-01-15 Various updates I forgot to commit previously
2017-01-15 Component map for LFK78 RevC/D
2017-01-22 TKL layout
2017-01-22 Added mini-MELF option for diodes. Script continues after answering 'n' for overwrite confirmation.
2017-01-24 Fixed new bugs in create/skip
2017-01-24 Make layout.py Windows compatible
2017-01-24 fix project template creation skip
2017-01-25 add Python 3 compatible version of layout.py
