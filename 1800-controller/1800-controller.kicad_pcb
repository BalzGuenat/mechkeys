# Repository BalzGuenat/mechkeys

File README.md:

# mechkeys

A few mechanical keyboard related kicad projects.

[103-key](http://www.keyboard-layout-editor.com/##@@=PrtSc&=Scroll%20Lock&=Pause%0ABreak&_x:1.25%3B&=Esc&_x:1%3B&=F1&=F2&=F3&=F4&_x:0.5%3B&=F5&=F6&=F7&=F8&_x:0.5%3B&=F9&=F10&=F11&=F12&_x:0.25&a:7%3B&=Home&=End%3B&@_y:0.5%3B&=Num%20Lock&=%2F%2F&=*&=-&_x:0.25&a:4%3B&=%7E%0A%60&=!%0A1&=%2F@%0A2&=%23%0A3&=$%0A4&=%25%0A5&=%5E%0A6&=%2F&%0A7&=*%0A8&=%28%0A9&=%29%0A0&=%2F_%0A-&=+%0A%2F=&_w:2%3B&=Backspace&_x:0.25&a:7%3B&=Ins&=PgUp%3B&@_f:3%3B&=7%0AHome&=8%0A%E2%86%91&=9%0APgUp&_h:2%3B&=+&_x:0.25&a:4&w:1.5%3B&=Tab&=Q&=W&=E&=R&=T&=Y&=U&=I&=O&=P&=%7B&=%7D&_w:1.5%3B&=%7C&_x:0.25%3B&=Del&=PgDn%3B&@=4%0A%E2%86%90&=5&=6%0A%E2%86%92&_x:1.25&a:4&w:1.75%3B&=Caps%20Lock&=A&=S&=D&=F&=G&=H&=J&=K&=L&=%2F:&=%22&_w:2.25%3B&=Enter%3B&@=1%0AEnd&=2%0A%E2%86%93&=3%0APgDn&_h:2%3B&=Enter&_x:0.25&a:4&w:2.25%3B&=Shift&=Z&=X&=C&=V&=B&=N&=M&=%3C&=%3E&=%3F&_w:2.75%3B&=Shift&_x:0.25%3B&=%E2%86%91%3B&@_w:2%3B&=0%0AIns&=.%0ADel&_x:1.25&a:4&w:1.25%3B&=Ctrl&_w:1.25%3B&=Win&_w:1.25%3B&=Alt&_w:6.25%3B&=&_a:4&w:1.25%3B&=Alt&_w:1.25%3B&=Win&_w:1.25%3B&=Menu&_x:0.5&a:7%3B&=%E2%86%90&=%E2%86%93&=%E2%86%92): A layout from w00dyallen in this post: [my_dream_layout_103key_99](https://www.reddit.com/r/MechanicalKeyboards/comments/4l9j7y/my_dream_layout_103key_99/)

[68+10](http://www.keyboard-layout-editor.com/##@_name=MF68+10%3B&@_a:7%3B&=F1&=F2&_x:0.25&a:4%3B&=~%0A%60&=!%0A1&=%2F@%0A2&=%23%0A3&=$%0A4&=%25%0A5&=^%0A6&=%2F&%0A7&=*%0A8&=%28%0A9&=%29%0A0&=%2F_%0A-&=+%0A%2F=&_w:2%3B&=Backspace&_x:0.25&a:7%3B&=Ins&=PgUp%3B&@=F3&=F4&_x:0.25&w:1.5%3B&=Tab&=Q&=W&=E&=R&=T&=Y&=U&=I&=O&=P&={&=}&_w:1.5%3B&=|&_x:0.25%3B&=Del&=PgDn%3B&@=F5&=F6&_x:0.25&w:1.75%3B&=Caps%20Lock&=A&=S&=D&=F&=G&=H&=J&=K&=L&=%2F:&=%22&_w:2.25%3B&=Enter%3B&@=F7&=F8&_x:0.25&w:2.25%3B&=Shift&=Z&=X&=C&=V&=B&=N&=M&=%3C&=%3E&=%3F&_w:2.75%3B&=Shift&_x:0.25%3B&=%E2%86%91%3B&@=F9&=F10&_x:0.25&w:1.25%3B&=Ctrl&_w:1.25%3B&=Win&_w:1.25%3B&=Alt&_w:6.25%3B&=&_a:4&w:1.25%3B&=Alt&_w:1.25%3B&=Win&_w:1.25%3B&=Menu&_x:0.5&a:7%3B&=%E2%86%90&=%E2%86%93&=%E2%86%92): The 'new' 68 key layout with an f-key block on the left. 

layout.py: python script that will layout out a pcb and schematic from the output of http://www.keyboard-layout-editor.com/

dylibfix.sh: shell script that will fix the lib security errors in osx.

## KiCad design 1800-controller/1800-controller.kicad_pcb

Parts:
C1, C3: 1µF; C_0603_HandSoldering
C2, C10: 4.7µF; Tantalum_Case-S_EIA-3216-12_Reflow
C4, C11, C27: 0.1µF; C_0603_HandSoldering
C5, C13: 0.01µF; C_0603_HandSoldering
C6, C7: 20pF; C_0603_HandSoldering
C8, C9: C; C_0603_HandSoldering
C12: 220µF; Tantalum_Case-X_EIA-7343-43_Reflow
C14: 47µF; Tantalum_Case-S_EIA-3216-12_Reflow
C15, C16, C17, C18, C19, C20: 22pF; C_0603_HandSoldering
C21, C22, C23, C24, C25, C26: 47pF; C_0603_HandSoldering
D1, D2: SN65220; SOT-23-6_Handsoldering
D3, D4: D_Zener; SOD-323_HandSoldering
IC1: ATTINY45-S; SOIC-8_3.9x4.9mm_Pitch1.27mm
L1: Ferrite_Bead_Small; Choke_SMD_1206_Standard
P1: USB_OTG; USB_Mini-B
P2: USB_A
P3: CONN_01X08; Molex_PicoBlade_53261-0871_08x1.25mm_Angled
R1, R5, R6, R8, R15, R16, R17, R18, R19, R20: 15k; R_0603_HandSoldering
R2, R4, R9, R10, R11, R12, R13, R14: 30; R_0603_HandSoldering
R3: 1.5k; R_0805_HandSoldering
R7: R; R_0603_HandSoldering
R21: 1.7k; R_0805_HandSoldering
R22, R23: 68; R_0603_HandSoldering
U1: TPS76333; SOT-23-5
U2: TUSB2036; LQFP-32_7x7mm_Pitch0.8mm
U3: TPS2041B; SOT-23-5
Y1: Crystal_GND3; Crystal_SMD_5032_4Pads

Connections:
+3V3: C2.1, C4.1, C5.1, R1.2, R5.1, R6.1, R8.2, U1.5 (VOUT), U2.3 (VCC), U2.6 (EEDATA/~GANGED), U2.23 (NPINT1), U2.24 (~NP3), U2.25 (VCC), U2.26 (~EXTMEM)
+5V: C1.1, C10.1, C11.1, C27.1, IC1.8 (VCC), P1.1 (VBUS), P3.1, R21.2, U1.1 (VIN), U1.3 (EN), U3.5 (IN)
D0+: C6.1, D1.4 (B), R2.1, R3.2, U2.1 (DP0)
D0-: C7.1, D1.6 (A), R4.1, U2.2 (DM0)
D1+: C20.1, R9.1, U2.12 (DP1)
D1-: C19.1, R10.1, U2.11 (DM1)
D1D+: C26.1, D3.1 (K), R9.2, R20.1, R22.1
D1D-: C25.1, D4.1 (K), R10.2, R19.1, R21.1, R23.1
D2+: C18.1, R11.1, U2.16 (DP2)
D2-: C17.1, R12.1, U2.15 (DM2)
D2D+: C24.1, P3.8, R11.2, R18.1
D2D-: C23.1, P3.7, R12.2, R17.1
D3+: C16.1, R13.1, U2.20 (DP3)
D3-: C15.1, R14.1, U2.19 (DM3)
D3D+: C22.1, D2.4 (B), P2.3 (D+), R13.2, R16.1
D3D-: C21.1, D2.6 (A), P2.2 (D-), R14.2, R15.1
D+: P1.3 (D+), R2.2
D-: P1.2 (D-), R4.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D1.2 (GND), D1.5 (GND), D2.2 (GND), D2.5 (GND), D3.2 (A), D4.2 (A), IC1.4 (GND), P1.5 (GND), P1.6 (shield), P2.4 (GND), P2.5 (shield), P3.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, U1.2 (GND), U2.7 (GND), U2.8 (~BUSPWR), U2.21 (~OCPROT~/~PWRSW~), U2.22 (NPINT0), U2.28 (GND), U2.31 (MODE), U3.2 (GND), Y1.3
MISO: IC1.6 (PB1(MISO/DO/AIN1/OC0B/OC1A/PCINT1)), P3.4
MOSI: IC1.5 (PB0(MOSI/DI/SDA/AIN0/OC0A/~OC1A~/AREF/P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), P3.3
unnamed: C8.1, U2.30 (XTAL1/CLK48), Y1.1
unnamed: C9.1, R7.2, Y1.2
unnamed: C12.1, L1.2, U3.1 (OUT)
unnamed: IC1.2 (PB3(XTAL1/CLKI/~OC1B~/ADC3/PCINT3)), R22.2
unnamed: IC1.3 (PB4(XTAL2/CLKO/OC1B/ADC2/PCINT4)), R23.2
unnamed: R3.1, U2.27 (DP0PUR)
unnamed: R5.2, U2.10 (~OVRCUR1)
unnamed: R6.2, U2.14 (~OVRCUR2)
unnamed: R7.1, U2.29 (XTAL2)
OVRCUR3: R8.1, U2.18 (~OVRCUR3), U3.3 (~OC)
PWRON3: U2.17 (~PWRON3), U3.4 (~EN)
RESET: IC1.1 (PB5(~RESET~/dW/ADC0/PCINT5)), P3.6
RST: C3.1, R1.1, U2.4 (~RESET)
SCK: IC1.7 (PB2(SCK/USCK/SCL/T0/INT0/ADC1/PCINT2)), P3.5
VBUS3: C13.1, C14.1, L1.1, P2.1 (VBUS)

Board: 2 copper layers, 100.0 x 45.0 mm, 63 parts (0 on the bottom side), 36 nets.

## KiCad design isp/isp.kicad_pcb

Board: 2 copper layers, 38.1 x 20.3 mm, 10 parts (0 on the bottom side), 11 nets.

Parts:
C1: 0.1µF; C_0805_HandSoldering
D1, D2: 3.6v; SOD-123
F1: F_Small; C_1206_HandSoldering
IC1: ATTINY45-S; SOIC-8_3.9x4.9mm_Pitch1.27mm
P1: USB_OTG; USB_Mini-B
P2: CONN_02X03; Pin_Header_Straight_2x03
R1: 1.7kΩ; R_0805_HandSoldering
R2, R3: 68Ω; R_0805_HandSoldering

Connections:
+5V: C1.1, F1.1, IC1.8, P2.2, R1.1
D+: D1.1, P1.3, R2.2
D-: D2.1, P1.2, R1.2, R3.2
GND: C1.2, D1.2, D2.2, IC1.4, P1.5, P1.6, P2.6
MISO: IC1.6, P2.1
MOSI: IC1.5, P2.4
unnamed: F1.2, P1.1
unnamed: IC1.2, R2.1
unnamed: IC1.3, R3.1
RST: IC1.1, P2.5
SCK: IC1.7, P2.3

## KiCad design a1800-compat/a1800-compat.kicad_pcb

Parts:
C1, C2: 18pF; C_0805_HandSoldering
C3: 4.7µF; TantalC_SizeA_EIA-3216_HandSoldering
C4, C5, C6, C7, C8: 0.1µF; C_0805_HandSoldering
C9: 1µF; C_0805_HandSoldering
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D55, D56, D57, D58, D59, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D74, D75, D76, D77, D78, D80, D81, D82, D83, D84, D85, D86, D87, D88, D89, D90, D91, D92, D93, D94, D95, D96, D97, D99, D101, D102, D104, D108, D109, D111, D112, D113, D114, D115: D
F1: FP_Small; Fuse_SMD1206_HandSoldering
P1: USB_B; USB_Mini-B
P2: CONN_02X03; Pin_Header_Angled_2x03
R1, R2: 22Ω; R_0805_HandSoldering
R3: 10kΩ; R_0805_HandSoldering
R4, R5, R6, R7, R8: 4.7kΩ; R_0805_HandSoldering
RGB1: Led_RGB_CA; SMP4-RGB-PIPE
SW1: SW_PUSH; SW_SPST_EVQP0
SW_1, SW_2, SW_3, SW_4, SW_5, SW_6, SW_7, SW_8, SW_9, SW_10, SW_11, SW_12, SW_13, SW_14, SW_15, SW_16, SW_17, SW_18, SW_19, SW_20, SW_21, SW_22, SW_23, SW_24, SW_25, SW_26, SW_27, SW_28, SW_29, SW_30, SW_31, SW_32, SW_33, SW_34, SW_35, SW_36, SW_37, SW_38, SW_39, SW_40, SW_41, SW_42, SW_43, SW_44, SW_45, SW_46, SW_47, SW_48, SW_49, SW_50, SW_51, SW_52, SW_53, SW_54, SW_55, SW_56, SW_57, SW_58, SW_59, SW_60, SW_61, SW_62, SW_63, SW_64, SW_65, SW_66, SW_67, SW_68, SW_69, SW_70, SW_71, SW_72, SW_73, SW_74, SW_75, SW_76, SW_77, SW_78, SW_79, SW_80, SW_81, SW_82, SW_83, SW_84, SW_85, SW_86, SW_87, SW_88, SW_89, SW_90, SW_91, SW_92, SW_93, SW_94, SW_95, SW_96, SW_97, SW_98, SW_99, SW_100, SW_101, SW_102, SW_103, SW_104, SW_105, SW_106, SW_107, SW_108, SW_109, SW_110, SW_111, SW_112, SW_113, SW_114, SW_115: MX_LED
U1: AT90USB1286; TQFP-64_14x14mm_Pitch0.8mm
Y1: 16Mhz; Crystal_SMD_5032_4Pads

Connections:
+5V: C3.1, C4.1, C5.1, C6.1, C7.1, F1.2, P2.2, R3.1, R4.1, R5.1, RGB1.1, U1.3 (UVCC), U1.8 (VBUS), U1.21 (VCC), U1.52 (VCC), U1.64 (AVCC)
AUDIO: U1.41 ((A14/OC.3A)PC6)
C1: SW_1.SW1, SW_22.SW1, SW_40.SW1, SW_59.SW2, SW_60.SW1, SW_78.SW1, SW_79.SW1, SW_97.SW1, SW_98.SW1, U1.51 ((AD0)PA0); also elsewhere on the board
C2: SW_2.SW1, SW_23.SW1, SW_41.SW1, SW_61.SW1, SW_80.SW1, SW_99.SW1, SW_100.SW2, U1.50 ((AD1)PA1); also elsewhere on the board
C3: SW_3.SW1, SW_24.SW1, SW_42.SW1, SW_62.SW1, SW_81.SW1, SW_101.SW1, U1.49 ((AD2)PA2); also elsewhere on the board
C4: SW_4.SW1, SW_25.SW1, SW_43.SW1, SW_63.SW1, SW_82.SW1, U1.48 ((AD3)PA3)
C5: SW_5.SW1, SW_26.SW1, SW_44.SW1, SW_64.SW1, SW_83.SW1, U1.47 ((AD4)PA4)
C6: SW_6.SW1, SW_27.SW1, SW_45.SW1, SW_65.SW1, SW_84.SW1, U1.46 ((AD5)PA5)
C7: SW_7.SW1, SW_28.SW1, SW_46.SW1, SW_66.SW1, SW_85.SW1, SW_102.SW1, SW_103.SW2, U1.45 ((AD6)PA6); also elsewhere on the board
C8: SW_8.SW1, SW_29.SW1, SW_47.SW1, SW_67.SW1, SW_86.SW1, U1.44 ((AD7)PA7)
C9: SW_9.SW1, SW_30.SW1, SW_48.SW1, SW_68.SW1, SW_87.SW1, U1.1 ((INT6/AIN0)PE6)
C10: SW_10.SW1, SW_31.SW1, SW_49.SW1, SW_69.SW1, SW_88.SW1, U1.2 ((INT.7/AIN.1/UVcon)PE7); also elsewhere on the board
C12: SW_12.SW1, SW_33.SW1, SW_51.SW1, SW_71.SW1, SW_90.SW1, SW_107.SW2, SW_108.SW1, SW_109.SW2, U1.60 ((ADC1)PF1)
C13: SW_13.SW1, SW_34.SW1, SW_52.SW1, SW_72.SW1, SW_73.SW1, SW_91.SW1, SW_110.SW1, U1.59 ((ADC2)PF2)
C14: SW_35.SW1, SW_53.SW1, SW_54.SW2, SW_96.SW1, SW_113.SW1, U1.58 ((ADC3)PF3)
C15: SW_14.SW1, SW_18.SW1, SW_36.SW1, SW_55.SW1, SW_74.SW1, SW_92.SW1, SW_114.SW1, U1.57 ((ADC4/TCK)PF4)
C16: SW_15.SW1, SW_19.SW1, SW_37.SW1, SW_56.SW1, SW_75.SW1, SW_93.SW1, SW_115.SW1, U1.56 ((ADC5/TMS)PF5)
C17: SW_16.SW1, SW_20.SW1, SW_38.SW1, SW_57.SW1, SW_76.SW1, SW_94.SW1, SW_111.SW1, U1.55 ((ADC6/TDO)PF6)
C18: SW_17.SW1, SW_21.SW1, SW_39.SW1, SW_58.SW1, SW_77.SW1, SW_95.SW1, SW_112.SW1, U1.54 ((ADC7/TDI)PF7)
D+: R2.1, U1.5 (D+)
D-: R1.1, U1.4 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, P1.4 (GND), P1.5 (shield), P2.6, SW1.1, U1.6 (UGND), U1.22 (GND), U1.43 ((~HWB~)PE2), U1.53 (GND), U1.63 (GND)
LED_SCL: R4.2, U1.25 ((OC0B/SCL/INT0)PD0)
LED_SDA: R5.2, U1.26 ((OC2B/SDA/INT1)PD1)
MISO: P2.1, U1.13 ((PDO/MISO/PCINT3)PB3)
MOSI: P2.4, U1.12 ((PDI/MOSI/PCINT2)PB2)
unnamed: C1.1, U1.24 (XTAL1), Y1.1
unnamed: C2.1, U1.23 (XTAL2), Y1.2
unnamed: C8.1, U1.7 (UCAP)
unnamed: C9.1, U1.62 (AREF)
unnamed: D1.2 (A), SW_1.SW2
unnamed: D2.2 (A), SW_2.SW2
unnamed: D3.2 (A), SW_3.SW2
unnamed: D4.2 (A), SW_4.SW2
unnamed: D5.2 (A), SW_5.SW2
unnamed: D6.2 (A), SW_6.SW2
unnamed: D7.2 (A), SW_7.SW2
unnamed: D8.2 (A), SW_8.SW2
unnamed: D9.2 (A), SW_9.SW2
unnamed: D10.2 (A), SW_10.SW2
unnamed: D11.2 (A), SW_11.SW2
unnamed: D12.2 (A), SW_12.SW2
unnamed: D13.2 (A), SW_13.SW2
unnamed: D14.2 (A), SW_14.SW2
unnamed: D15.2 (A), SW_15.SW2
unnamed: D16.2 (A), SW_16.SW2
unnamed: D17.2 (A), SW_17.SW2
unnamed: D18.2 (A), SW_18.SW2
unnamed: D19.2 (A), SW_19.SW2
unnamed: D20.2 (A), SW_20.SW2
unnamed: D21.2 (A), SW_21.SW2
unnamed: D22.2 (A), SW_22.SW2
unnamed: D23.2 (A), SW_23.SW2
unnamed: D24.2 (A), SW_24.SW2
unnamed: D25.2 (A), SW_25.SW2
unnamed: D26.2 (A), SW_26.SW2
unnamed: D27.2 (A), SW_27.SW2
unnamed: D28.2 (A), SW_28.SW2
unnamed: D29.2 (A), SW_29.SW2
unnamed: D30.2 (A), SW_30.SW2
unnamed: D31.2 (A), SW_31.SW2
unnamed: D32.2 (A), SW_32.SW2
unnamed: D33.2 (A), SW_33.SW2
unnamed: D34.2 (A), SW_34.SW2
unnamed: D35.2 (A), SW_35.SW2
unnamed: D36.2 (A), SW_36.SW2
unnamed: D37.2 (A), SW_37.SW2
unnamed: D38.2 (A), SW_38.SW2
unnamed: D39.2 (A), SW_39.SW2
unnamed: D40.2 (A), SW_40.SW2
unnamed: D41.2 (A), SW_41.SW2
unnamed: D42.2 (A), SW_42.SW2
unnamed: D43.2 (A), SW_43.SW2
unnamed: D44.2 (A), SW_44.SW2
unnamed: D45.2 (A), SW_45.SW2
unnamed: D46.2 (A), SW_46.SW2
unnamed: D47.2 (A), SW_47.SW2
unnamed: D48.2 (A), SW_48.SW2
unnamed: D49.2 (A), SW_49.SW2
unnamed: D50.2 (A), SW_50.SW2
unnamed: D51.2 (A), SW_51.SW2
unnamed: D52.2 (A), SW_52.SW2
unnamed: D53.2 (A), SW_53.SW2, SW_54.SW1
unnamed: D55.2 (A), SW_55.SW2
unnamed: D56.2 (A), SW_56.SW2
unnamed: D57.2 (A), SW_57.SW2
unnamed: D58.2 (A), SW_58.SW2
unnamed: D59.2 (A), SW_59.SW1, SW_60.SW2
unnamed: D61.2 (A), SW_61.SW2
unnamed: D62.2 (A), SW_62.SW2
unnamed: D63.2 (A), SW_63.SW2
unnamed: D64.2 (A), SW_64.SW2
unnamed: D65.2 (A), SW_65.SW2
unnamed: D66.2 (A), SW_66.SW2
unnamed: D67.2 (A), SW_67.SW2
unnamed: D68.2 (A), SW_68.SW2
unnamed: D69.2 (A), SW_69.SW2
unnamed: D70.2 (A), SW_70.SW2
unnamed: D71.2 (A), SW_71.SW2
unnamed: D72.2 (A), SW_72.SW2, SW_73.SW2
unnamed: D74.2 (A), SW_74.SW2
unnamed: D75.2 (A), SW_75.SW2
unnamed: D76.2 (A), SW_76.SW2
unnamed: D77.2 (A), SW_77.SW2
unnamed: D78.2 (A), SW_78.SW2, SW_79.SW2
unnamed: D80.2 (A), SW_80.SW2
unnamed: D81.2 (A), SW_81.SW2
unnamed: D82.2 (A), SW_82.SW2
unnamed: D83.2 (A), SW_83.SW2
unnamed: D84.2 (A), SW_84.SW2
unnamed: D85.2 (A), SW_85.SW2
unnamed: D86.2 (A), SW_86.SW2
unnamed: D87.2 (A), SW_87.SW2
unnamed: D88.2 (A), SW_88.SW2
unnamed: D89.2 (A), SW_89.SW2
unnamed: D90.2 (A), SW_90.SW2
unnamed: D91.2 (A), SW_91.SW2
unnamed: D92.2 (A), SW_92.SW2
unnamed: D93.2 (A), SW_93.SW2
unnamed: D94.2 (A), SW_94.SW2
unnamed: D95.2 (A), SW_95.SW2
unnamed: D96.2 (A), SW_96.SW2
unnamed 126: D97.2 (A), SW_97.SW2, SW_98.SW2; also elsewhere on the board
unnamed 127: D102.2 (A), SW_102.SW2, SW_103.SW1; also elsewhere on the board
unnamed: D108.2 (A), SW_107.SW1, SW_108.SW2
unnamed: D109.2 (A), SW_109.SW1, SW_110.SW2
unnamed: D111.2 (A), SW_111.SW2
unnamed: D112.2 (A), SW_112.SW2
unnamed: D113.2 (A), SW_113.SW2
unnamed: D114.2 (A), SW_114.SW2
unnamed: D115.2 (A), SW_115.SW2
unnamed: F1.1, P1.1 (VCC)
unnamed: R6.1, RGB1.2 (R)
unnamed: R7.1, RGB1.3 (G)
unnamed: R8.1, RGB1.4 (B)
PWM_BLUE: R8.2, U1.17 ((PCINT7/OC.0A/OC.1C)PB7)
PWM_GREEN: R7.2, U1.16 ((PCINT6/OC.1B)PB6)
PWM_RED: R6.2, U1.15 ((PCINT5/OC.1A)PB5)
R1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), U1.27 ((RXD1/INT2)PD2)
R2: D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), U1.28 ((TXD1/INT3)PD3)
R3: D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), U1.29 ((ICP1)PD4)
R4: D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), U1.30 ((XCK1)PD5)
R5: D59.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K), D72.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), U1.31 ((T1)PD6)
R6: D78.1 (K), D80.1 (K), D81.1 (K), D82.1 (K), D83.1 (K), D84.1 (K), D85.1 (K), D86.1 (K), D87.1 (K), D88.1 (K), D89.1 (K), D90.1 (K), D91.1 (K), D92.1 (K), D93.1 (K), D94.1 (K), D95.1 (K), D96.1 (K), U1.32 ((T0)PD7)
R7: D97.1 (K), D99.1 (K), D101.1 (K), D102.1 (K), D104.1 (K), D108.1 (K), D109.1 (K), D111.1 (K), D112.1 (K), D113.1 (K), D114.1 (K), D115.1 (K), U1.33 ((~WR~)PE0); also elsewhere on the board
RESET: P2.5, R3.2, SW1.2, U1.20 (~RESET~)
SCK: P2.3, U1.11 ((SCLK/PCINT1)PB1)
USB+: P1.3 (D+), R2.2
USB-: P1.2 (D-), R1.2
